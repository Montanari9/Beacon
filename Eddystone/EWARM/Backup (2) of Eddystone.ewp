# IAR project Backup (2) of Eddystone.ewp, settings and files
configuration Eddystone Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053x8 ST STM32L053x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L053xx
  ICCARM.CCIncludePath2: ..\Inc; ..\Drivers\STM32L0xx_HAL_Driver\Inc; ..\Drivers\STM32L0xx_HAL_Driver\Inc\Legacy; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32L0xx\Include; ..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes; ..\Drivers\BSP\X-NUCLEO-IDB04A1\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Eddystone.sim
  ILINK.IlinkOutputFile: Eddystone Configuration.out
  ILINK.IlinkIcfFile: stm32l053xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/iar/: startup_stm32l053xx.s
  group Application/User
    ../Src/: adc.c dma.c eddystone_tlm_service.c eddystone_uid_service.c eddystone_url_service.c gpio.c main.c rtc.c spi.c stm32l0xx_hal_msp.c stm32l0xx_it.c
  group Drivers/BSP/X-NUCLEO-IDB04A1
    ../Drivers/BSP/X-NUCLEO-IDB04A1/Src/: x-nucleo-idb04a1.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c
  group Middlewares/STM32_BlueNRG/HCI
    ../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/: hci.c
  group Middlewares/STM32_BlueNRG/HCI/controller
    ../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c
  group Middlewares/STM32_BlueNRG/Interface
    ../Src/: bluenrg_itf.c
  group Middlewares/STM32_BlueNRG/Utils
    ../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/utils/: list.c osal.c
